# Keil uVision project DHT11_ToOneNetByMqtt.uvprojx, settings and files
target 工程 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYS;..\HARDWARE\scr\MQ_Sensor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: stm32f10x_it.c delay.c usart1.c usart2.c timer2.c timer3.c timer4.c wifi.c mqtt.c dht11.c control.c led.c oled.c MQ_4.c Fire.c OLED_Show.c
    ../HARDWARE/scr/MQ_Sensor/: MQ-Sensor.c
    ../HARDWARE/inc/: oled.h oledfont.h MQ_4.h Fire.h
    ./: bmp.c bmp.h
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dac.c stm32f10x_adc.c
  group SYS
    ../SYS/: sys.c
